options:
  parameters:
    author: andrea
    generate_options: qt_gui
    id: tx
    output_language: python
    title: hackrf's sending file
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 80e6
    step: 200k
    stop: 107.6e6
    value: 80e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: 4*audio_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: 4*audio_rate
    tau: 26e6
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/andrea/Scaricati/Alesis-Fusion-Acoustic-Bass-C2.wav
    repeat: 'True'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '45'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
