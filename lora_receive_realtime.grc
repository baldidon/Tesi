options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: lora_receive_realtime
    output_language: python
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: sf * (1 / (2**sf / float(bw)))
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: capture_freq
  id: variable
  parameters:
    value: 867.3e6
  states: {}
- name: capture_freq_0
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: decimation
  id: variable
  parameters:
    comment: |-
      The decimation determines the oversampling rate.
      A sample rate of 1e6 and decimation of 1 equals
      8 times oversampling, a decimation of 2 is 4 times
      oversampling, and so on. Set higher decimation
      for better performance, but worse accuracy.
    value: '1'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '9'
  states: {}
- name: symbols_per_sec
  id: variable
  parameters:
    value: float(bw) / (2**sf)
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 867.3e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-200000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '7'
  states: {}
- name: lora_lora_receiver_0_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '7'
  states: {}
- name: lora_lora_receiver_0_0_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '7'
  states: {}
- name: lora_lora_receiver_0_1
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '8'
  states: {}
- name: lora_lora_receiver_0_1_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '9'
  states: {}
- name: lora_lora_receiver_0_1_0_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '9'
  states: {}
- name: lora_lora_receiver_0_1_0_1
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '9'
  states: {}
- name: lora_lora_receiver_0_1_0_1_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '9'
  states: {}
- name: lora_lora_receiver_0_1_1
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '8'
  states: {}
- name: lora_lora_receiver_0_1_2
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '8'
  states: {}
- name: lora_lora_receiver_0_1_2_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '8'
  states: {}
- name: lora_lora_receiver_0_2
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '10'
  states: {}
- name: lora_lora_receiver_0_2_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '10'
  states: {}
- name: lora_lora_receiver_0_2_1
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '10'
  states: {}
- name: lora_lora_receiver_0_2_1_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '10'
  states: {}
- name: lora_lora_receiver_0_3
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'False'
    decimation: decimation
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: '7'
  states: {}
- name: lora_message_socket_sink_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_0_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_0_0_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_0_0_0_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_0_0_0_0_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_0_0_0_1
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_0_0_1
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_0_0_1_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_0_0_2
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_0_1
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_0_1_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_0_2
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_1
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_1_0
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: lora_message_socket_sink_0_2
  id: lora_message_socket_sink
  parameters:
    ip: 127.0.0.1
    layer: '2'
    port: '4446'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: capture_freq
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: capture_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0_0_0_0, '0']
- [blocks_multiply_xx_0, '0', lora_lora_receiver_0_0, '0']
- [blocks_multiply_xx_0, '0', lora_lora_receiver_0_1_0_1, '0']
- [blocks_multiply_xx_0, '0', lora_lora_receiver_0_1_2, '0']
- [blocks_multiply_xx_0, '0', lora_lora_receiver_0_2_1, '0']
- [blocks_multiply_xx_0_0_0, '0', lora_lora_receiver_0_1_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', lora_lora_receiver_0_1_1, '0']
- [blocks_multiply_xx_0_0_0, '0', lora_lora_receiver_0_2_0, '0']
- [blocks_multiply_xx_0_0_0, '0', lora_lora_receiver_0_3, '0']
- [blocks_multiply_xx_0_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_multiply_xx_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0, '1']
- [blocks_multiply_xx_0_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0_0, '1']
- [blocks_multiply_xx_0_0_0_0_0_0, '0', lora_lora_receiver_0_0_0, '0']
- [blocks_multiply_xx_0_0_0_0_0_0, '0', lora_lora_receiver_0_1_0_1_0, '0']
- [blocks_multiply_xx_0_0_0_0_0_0, '0', lora_lora_receiver_0_1_2_0, '0']
- [blocks_multiply_xx_0_0_0_0_0_0, '0', lora_lora_receiver_0_2_1_0, '0']
- [lora_lora_receiver_0, frames, lora_message_socket_sink_0, in]
- [lora_lora_receiver_0_0, frames, lora_message_socket_sink_0_1, in]
- [lora_lora_receiver_0_0_0, frames, lora_message_socket_sink_0_1_0, in]
- [lora_lora_receiver_0_1, frames, lora_message_socket_sink_0_0, in]
- [lora_lora_receiver_0_1_0, frames, lora_message_socket_sink_0_0_0_0, in]
- [lora_lora_receiver_0_1_0_0, frames, lora_message_socket_sink_0_0_0_0_1, in]
- [lora_lora_receiver_0_1_0_1, frames, lora_message_socket_sink_0_0_0_0_0, in]
- [lora_lora_receiver_0_1_0_1_0, frames, lora_message_socket_sink_0_0_0_0_0_0, in]
- [lora_lora_receiver_0_1_1, frames, lora_message_socket_sink_0_0_2, in]
- [lora_lora_receiver_0_1_2, frames, lora_message_socket_sink_0_0_1, in]
- [lora_lora_receiver_0_1_2_0, frames, lora_message_socket_sink_0_0_1_0, in]
- [lora_lora_receiver_0_2, frames, lora_message_socket_sink_0_0_0, in]
- [lora_lora_receiver_0_2_0, frames, lora_message_socket_sink_0_0_0_2, in]
- [lora_lora_receiver_0_2_1, frames, lora_message_socket_sink_0_0_0_1, in]
- [lora_lora_receiver_0_2_1_0, frames, lora_message_socket_sink_0_0_0_1_0, in]
- [lora_lora_receiver_0_3, frames, lora_message_socket_sink_0_2, in]
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0_0_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0_0_0_0_0_0, '0']
- [rtlsdr_source_0, '0', lora_lora_receiver_0, '0']
- [rtlsdr_source_0, '0', lora_lora_receiver_0_1, '0']
- [rtlsdr_source_0, '0', lora_lora_receiver_0_1_0, '0']
- [rtlsdr_source_0, '0', lora_lora_receiver_0_2, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
